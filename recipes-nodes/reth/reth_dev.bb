include reth.inc

SRC_URI = "git://github.com/paradigmxyz/reth;protocol=git;branch=main"
SRCREV = "${AUTOREV}"
